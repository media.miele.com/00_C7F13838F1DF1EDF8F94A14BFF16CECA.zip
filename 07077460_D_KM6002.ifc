Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 37215c33-eab6-4e59-8f0a-9038e5900a97, NumberOfSaves: 1]
File name: 0001
Time: 2024-07-01T11:49:40+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 07077460_D_KM6002:26600252_D_7077460_KM6002, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_Cast, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26600252_D_7077460_KM6002; sets with these values: 2
